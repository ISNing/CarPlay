# Keil uVision project CarPlay.uvproj, settings and files
target Target (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CarPlay +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: main.c
  group deps
    ./: delay.c pwm.c pid.c
